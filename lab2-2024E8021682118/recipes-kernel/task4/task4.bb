SUMMARY = "2024E8021682118 Task4: IO Memory Operations"
LICENSE = "GPL-2.0"
inherit module

SRC_URI = " \
    file://2024E8021682118_task4.c \
    file://Makefile \
"

S = "${WORKDIR}"