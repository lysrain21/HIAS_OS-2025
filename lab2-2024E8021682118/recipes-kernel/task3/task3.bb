SUMMARY = "2024E8021682118 Task3: MMIO Operations"
LICENSE = "GPL-2.0"
inherit module

SRC_URI = " \
    file://2024E8021682118_task3.c \
    file://Makefile \
"

S = "${WORKDIR}"