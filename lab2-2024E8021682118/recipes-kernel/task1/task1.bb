SUMMARY = "2024E8021682118 Task1: kmalloc Memory Allocation"
LICENSE = "GPL-2.0"
inherit module

SRC_URI = " \
    file://2024E8021682118_task1.c \
    file://Makefile \
"

S = "${WORKDIR}"